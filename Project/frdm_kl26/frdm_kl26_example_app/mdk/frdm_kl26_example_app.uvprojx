# Keil uVision project frdm_kl26_example_app.uvprojx, settings and files
target frdm_kl26 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL26Z64xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF800,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm_kl26_example_app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: MKL26Z4   DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_kl\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: BOOTLOADER
  memory RVCT4: ROM 0x8000 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  group startup_mkl26
    ../../../../Libraries/startup/src/: system_MKL26Z4.c
    ../../../../Libraries/startup/src/mdk/: startup_MKL26Z4.s
  group user
    ../src/: main.c
    ../src/config/: bl_cfg.h
  group drivers
    ../../../../Libraries/drivers_kl/src/: common.c flash.c gpio.c uart.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
