# Keil uVision project frdm_ke04_example.uvprojx, settings and files
target mke04 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKE04Z8VFK4 NXP
  pack: NXP.MKE04Z4_DFP.14.0.0
  cpu: IRAM(0x1fffff00,0x0400) IROM(0x00000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm_ke04_example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: v6Lang=1 v6LangP=1
  c define: MKE04Z4
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_ke\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: RAM_TARGET
  memory RVCT4: ROM 0xc00 size 0x1000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  group startup_mke04
    ../../../../Libraries/startup/src/: system_MKE04Z4.c
    ../../../../Libraries/startup/src/mdk/: startup_MKE04Z4.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers_ke/src/: common.c flash.c gpio.c uart.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
