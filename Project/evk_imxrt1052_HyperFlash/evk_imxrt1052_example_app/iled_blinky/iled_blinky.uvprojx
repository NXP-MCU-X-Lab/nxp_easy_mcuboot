# Keil uVision project iled_blinky.uvprojx, settings and files
target iled_blinky flexspi_nor_debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: iled_blinky.out +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, DEBUG, CPU_MIMXRT1052DVL6B, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;CMSIS;component/lists;component/serial_manager;component/uart;device;drivers;utilities;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor_0x60040000.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=0"
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group source
    source/: led_blinky.c
  group startup
    startup/: startup_MIMXRT1052.S
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
