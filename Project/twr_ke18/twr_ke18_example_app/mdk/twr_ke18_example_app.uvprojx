# Keil uVision project twr_ke18_example_app.uvprojx, settings and files
target mke18 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MKE18F512VLH16 NXP
  pack: NXP.MKE18F16_DFP.12.2.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff8000,0x8000) IROM(0x10000000,0x010000) IROM2(0x00000000,0x080000) XRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: frdm_ke15z_example_app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG MKE18F16
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_ke15\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x10008000 size 0x10000
  memory RVCT5: ROM 0x8000 size 0x80000
  memory RVCT6: RAM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group startup_mke18
    ../../../../Libraries/startup/src/: system_MKE18F16.c
    ../../../../Libraries/startup/src/mdk/: startup_MKE18F16.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers_ke15/src/: common.c gpio.c flash.c lpuart.c scg.c
