# Keil uVision project frdm_k64_example_app.uvprojx, settings and files
target frdm_k64_example_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: frdm_k64_example_app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: MK64F12
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_k64\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: RAM_TARGET
  memory RVCT4: ROM 0x8000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk64f12
    ../../../../Libraries/startup/src/: system_MK64F12.c
    ../../../../Libraries/startup/src/mdk/: startup_MK64F12.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers_k64/src/: common.c flash.c gpio.c uart.c
