# Keil uVision project frdm_mcxa153bl.uvprojx, settings and files
target frdm_mcxa153 (6190000::V6.19::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.19.0.0
  cpu: IRAM(0x20000000,0x6000) IRAM2(0x04000000,0x2000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x020000) XRAM(0x04002000,0x1000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: frdm_mcxa153_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: v6Lang=3 v6LangP=3
  c define: DEBUG MCXA153 MAX_PACKET_LEN=128
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_mcxa\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: MCXA153_flash.scf
  group startup_mcxa153
    ../../../../Libraries/startup/src/: system_MCXA153.c
    ../../../../Libraries/startup/src/mdk/: startup_MCXA153.S
  group user
    ../src/: main.c
    ../src/config/: bl_cfg.h
  group drivers
    ../../../../Libraries/drivers_mcxa/src/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c fsl_inputmux.c fsl_lpuart.c fsl_reset.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
