# Keil uVision project frdm_ke15_bl.uvprojx, settings and files
target mke15 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKE15Z256VLL7 NXP
  pack: NXP.MKE15Z7_DFP.12.1.0
  cpu: IRAM(0x14000000,0x0800) IRAM2(0x1fffe000,0x8000) IROM(0x10000000,0x8000) IROM2(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm_ke15_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG MKE15Z7
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_ke15\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x14000000 size 0x800
  memory RVCT10: RAM 0x1fffe000 size 0x8000
  group startup_mke15
    ../../../../Libraries/startup/src/: system_MKE15Z7.c
    ../../../../Libraries/startup/src/mdk/: startup_MKE15Z7.s
  group user
    ../src/: main.c
    ../src/config/: bl_cfg.h
  group drivers
    ../../../../Libraries/drivers_ke15/src/: common.c gpio.c flash.c lpuart.c scg.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
