# Keil uVision project frdm_ke02_example.uvprojx, settings and files
target mke02 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKE02Z64VLH4 NXP
  pack: NXP.MKE02Z4_DFP.10.0.3
  cpu: IRAM(0x1ffffc00,0x1000) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm_ke02_example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: v6Lang=1 v6LangP=1
  c define: MKE02Z4
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_ke\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: RAM_TARGET
  memory RVCT4: ROM 0x8000 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group startup_mke02
    ../../../../Libraries/startup/src/: system_MKE02Z4.c
    ../../../../Libraries/startup/src/mdk/: startup_MKE02Z4.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers_ke/src/: common.c flash.c gpio.c uart.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
