# Keil uVision project evk_imxrt1062_bl.uvprojx, settings and files
target imxrt1062 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.13.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt1062_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: MIMXRT1062, XIP_EXTERNAL_FLASH=1, BOOT_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG
  c misc: --c99 --diag_suppress=1296,177
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_rt1062\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config;..\src\board;..\src\xip
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf)
  group startup_imxrt1062
    ../../../../Libraries/startup/src/: system_MIMXRT1062.c
    ../../../../Libraries/startup/src/mdk/: startup_MIMXRT1062.s
  group user
    ../src/: main.c
    ../src/config/: bl_cfg.h
  group board
    ../src/board/: clock_config.c pin_mux.c
  group drivers
    ../../../../Libraries/drivers_rt1062/src/: common.c flash.c fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_romapi.c
    ../../../../Libraries/drivers_rt1062/inc/: fsl_clock.h
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
  group xip
    ../src/xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
