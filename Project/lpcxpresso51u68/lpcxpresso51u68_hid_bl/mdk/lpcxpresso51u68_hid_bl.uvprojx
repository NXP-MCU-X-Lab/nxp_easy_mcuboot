# Keil uVision project lpcxpresso51u68_hid_bl.uvprojx, settings and files
target lpcxpresso51u68_hid_bl (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC51U68JBD64 NXP
  pack: NXP.LPC51U68_DFP.13.1.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpcxpresso51u68_hid_bl +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG LPC51U68
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_lpc\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config;..\..\..\..\Libraries\utilities\chusb\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group startup_lpc51u68
    ../../../../Libraries/startup/src/: system_LPC51U68.c
    ../../../../Libraries/startup/src/mdk/: startup_LPC51U68.S
    ../../../../Libraries/startup/src/mdk/powerlib/lpc51u68/: keil_lib_power_m0.lib
  group user
    ../src/: main.c
    ../src/config/: bl_cfg.h usbd_config.h
  group drivers
    ../../../../Libraries/drivers_lpc/src/: common.c flash.c gpio.c syscon.c uart.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: hid_mcuboot.c
  group utilities\chusb
    ../../../../Libraries/utilities/chusb/src/: usbd.c usbd_hid.c usbd_lpc_driver.c usbd_descriptor.c
