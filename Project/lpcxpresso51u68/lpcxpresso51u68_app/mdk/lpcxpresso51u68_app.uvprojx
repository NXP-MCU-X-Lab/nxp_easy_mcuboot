# Keil uVision project lpcxpresso51u68_app.uvprojx, settings and files
target lpcxpresso51u68_app (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC51U68JBD64 NXP
  pack: NXP.LPC51U68_DFP.13.1.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpcxpresso51u68_app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG LPC51U68
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_lpc\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group startup_lpc51u68
    ../../../../Libraries/startup/src/: system_LPC51U68.c
    ../../../../Libraries/startup/src/mdk/: startup_LPC51U68.S
    ../../../../Libraries/startup/src/mdk/powerlib/lpc51u68/: keil_lib_power_m0.lib
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers_lpc/src/: common.c gpio.c syscon.c uart.c
