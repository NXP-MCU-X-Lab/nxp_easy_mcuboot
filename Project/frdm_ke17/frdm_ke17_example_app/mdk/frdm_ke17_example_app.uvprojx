# Keil uVision project frdm_ke17_example_app.uvprojx, settings and files
target mke17 (6160000::V6.16::ARMCLANG)
  device: MKE15Z256VLL7 NXP
  pack: NXP.MKE15Z7_DFP.14.0.0
  cpu: IRAM(0x14000000,0x0800) IRAM2(0x1fffe000,0x8000) IROM(0x10000000,0x8000) IROM2(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm_ke15z_example_app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG MKE17Z7
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_ke15\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x8000 size 0x40000
  memory RVCT9: RAM 0x14000000 size 0x800
  memory RVCT10: RAM 0x1fffe000 size 0x8000
  scatter file: ..\..\frdm_ke17_bl\mdk\MKE17Z256xxx7_flash.scf
  group startup_mke17
    ../../../../Libraries/startup/src/: system_MKE17Z7.c
    ../../../../Libraries/startup/src/mdk/: startup_MKE17Z7.S
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers_ke15/src/: common.c gpio.c flash.c lpuart.c scg.c
