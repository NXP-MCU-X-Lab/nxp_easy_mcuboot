# Keil uVision project frdm_ke17_bl.uvprojx, settings and files
target mke17z (6160000::V6.16::ARMCLANG)
  device: MKE17Z256VLL7 NXP
  pack: NXP.MKE17Z7_DFP.14.0.0
  cpu: IRAM(0x1fffc000,0xc000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm_ke17_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG MKE17Z7
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_ke15\inc;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0xc000
  scatter file: .\MKE17Z256xxx7_flash.scf
  group startup_mke17z
    ../../../../Libraries/startup/src/: system_MKE17Z7.c
    ../../../../Libraries/startup/src/mdk/: startup_MKE17Z7.S
  group user
    ../src/: main.c
    ../src/config/: bl_cfg.h
  group drivers
    ../../../../Libraries/drivers_ke15/src/: common.c gpio.c flash.c lpuart.c scg.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
