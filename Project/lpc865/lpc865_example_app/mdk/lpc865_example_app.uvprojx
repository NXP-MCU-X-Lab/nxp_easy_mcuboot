# Keil uVision project lpc865_example_app.uvprojx, settings and files
target lpc865_example_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC865M201JBD64 NXP
  pack: NXP.LPC865_DFP.14.0.0
  cpu: IRAM(0x10001fe0,0x20) IRAM2(0x10000000,0x1fe0) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc865_example +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c define: LPC865 __VTOR_PRESENT
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_lpc800\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\src\config;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x10000
  memory RVCT9: RAM 0x10001fe0 size 0x20
  memory RVCT10: RAM 0x10000000 size 0x1fe0
  group startup_lpc865
    ../../../../Libraries/startup/src/mdk/: startup_LPC8xx.s
    ../../../../Libraries/startup/src/: system_LPC865.c
  group user
    ../src/: main.c
  group drivers_lpc865
    ../../../../Libraries/drivers_lpc865/src/: common.c gpio.c syscon.c uart.c flash.c
