# Keil uVision project lpc804_bl.uvprojx, settings and files
target plc8xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC802M001JDH16 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IROM(0x00000000,0x00004000) IRAM(0x10000000,0x00000800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc804_bl +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c define: LPC802 __VTOR_PRESENT
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\src\config;..\..\..\..\Libraries\utilities\mcuboot;..\..\..\..\Libraries\utilities\kptl;..\..\src;..\..\lpc804_driver\inc
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x7f0
  group startup_lpc8xx
    ../../../../Libraries/startup/src/mdk/: startup_LPC804.s
    ../../../../Libraries/startup/src/: system_LPC804.c
  group user
    ../src/: main.c
  group user\config
    ../src/config/: bl_cfg.h
  group drivers_lpc800
    ../../lpc804_driver/src/: common.c flash.c gpio.c syscon.c uart.c
  group utilities\mcuboot
    ../../../../Libraries/utilities/mcuboot/: mcuboot.c
  group utilities\kptl
    ../../../../Libraries/utilities/kptl/: kptl.c
